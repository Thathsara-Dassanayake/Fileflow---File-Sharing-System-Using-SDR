options:
  parameters:
    author: L.H.H.Maduwantha
    generate_options: qt_gui
    id: mpsk_rrc_rolloff
    output_language: python
    title: mpsk_rcc_rolloff.grc
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0_4
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: 100m
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_4_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: 220m
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_4_1
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_4_2
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: '1'
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_4_3
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: 500m
    samples_per_symbol: sps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '5'
    type: complex
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_4, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_4_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_4_1, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_4_2, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_4_3, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_4, '0', blocks_throttle_0, '0']
- [digital_constellation_modulator_0_4_0, '0', qtgui_freq_sink_x_0, '1']
- [digital_constellation_modulator_0_4_1, '0', qtgui_freq_sink_x_0, '2']
- [digital_constellation_modulator_0_4_2, '0', qtgui_freq_sink_x_0, '4']
- [digital_constellation_modulator_0_4_3, '0', qtgui_freq_sink_x_0, '3']

metadata:
  file_format: 1
